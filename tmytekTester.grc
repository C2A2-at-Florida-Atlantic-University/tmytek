options:
  parameters:
    generate_options: qt_gui
    id: tmytekTester
    output_language: python
    title: TMYTEK Tester
  states: {}

blocks:
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '70'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '72'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '512'
    type: complex
  states: {state: disabled}
- name: epy_module_0
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\r\n# In the Python Module Block\r\nimport sys\r\nsys.path.append('C:/Users/pwfau/OneDrive/Documents/GNURadio/tmytekTesterCode.py')  # Add the directory of the file to the path\r\nimport tmytekTesterCode  # Import your custom module"
  states: {state: disabled}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: localhost
    mtu: '10000'
    port: '5002'
    type: UDP_SERVER
  states: {state: disabled}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1024'
    port: '5000'
    send_eof: 'False'
    type: complex
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    payloadsize: '4096'
    port: '5002'
    src_zeros: 'True'
    type: complex
  states: {}
- name: network_udp_source_0_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    payloadsize: '4096'
    port: '5010'
    src_zeros: 'False'
    type: complex
  states: {}
- name: network_udp_source_1
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    payloadsize: 512*8
    port: '5004'
    src_zeros: 'False'
    type: complex
  states: {}
- name: network_udp_source_1_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    payloadsize: 124*8
    port: '5006'
    src_zeros: 'False'
    type: complex
  states: {}
- name: network_udp_source_1_0_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    payloadsize: 124*8
    port: '5008'
    src_zeros: 'False'
    type: complex
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: pl
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"Rx Constellation"'
    size: '124'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    name: '"Tx Constellation"'
    size: '124'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Rx Sig"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Tx Sig"'
    size: '512'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Detected Rx Sig"'
    size: '512'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: 20e6
    center_freq0: 915e6
    clock_source0: external
    dev_addr: serial=3113F40
    gain0: tx_gain
    samp_rate: samp_rate
    stream_chans: '[0]'
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: 20e6
    center_freq0: 915e6
    clock_source0: external
    dev_addr: serial=3113F40
    gain0: rx_gain
    samp_rate: samp_rate
    stream_chans: '[1]'
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_stream_to_tagged_stream_0, '0', uhd_usrp_sink_0, '0']
- [network_socket_pdu_0, pdus, pdu_pdu_to_tagged_stream_0, pdus]
- [network_udp_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [network_udp_source_0, '0', uhd_usrp_sink_0, '0']
- [network_udp_source_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [network_udp_source_1, '0', qtgui_time_sink_x_0_0_0, '0']
- [network_udp_source_1_0, '0', qtgui_const_sink_x_0, '0']
- [network_udp_source_1_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', uhd_usrp_sink_0, '0']
- [uhd_usrp_source_0, '0', network_udp_sink_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
